<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>messageutils_pdu_debug</key>
<param><key>id</key><value>messageutils_pdu_debug_0</value></param>
<param><key>reverse_ascii</key><value>True</value></param>
<param><key>display</key><value>True</value></param>
<param><key>meta_only</key><value>False</value></param>
<param><key>vec_type</key><value>float</value></param>
</block>
<block>
<key>messageutils_pdu_splitter</key>
<param><key>id</key><value>messageutils_pdu_splitter_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>lengths</key><value>5,5</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>messageutils_vector_pdu_xx</key>
<param><key>id</key><value>messageutils_vector_pdu_xx_0</value></param>
<param><key>tag_output</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>type</key><value>f</value></param>
<param><key>pkt_lim</key><value>0</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>vector</key><value>[1,2,3,4,5,6,7,8,9,10]</value></param>
</block>
<connection><source_block_id>messageutils_pdu_splitter_0</source_block_id><sink_block_id>messageutils_pdu_debug_0</sink_block_id><source_key>out1</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>messageutils_vector_pdu_xx_0</source_block_id><sink_block_id>messageutils_pdu_splitter_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
</flow_graph>

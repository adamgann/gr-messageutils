<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pdu_source</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ascii_bytes</value></param>
<param><key>value</key><value>[84, 104, 105, 115, 32, 105, 115, 32, 97, 32, 116, 101, 115, 116]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>float_data</value></param>
<param><key>value</key><value> [0.3426 ,3.5784 ,2.7694,  0.5377, 1.8339, -2.2588, 0.8622, 0.3188, -1.3077, -0.4336]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>messageutils_vector_pdu_xx</key>
<param><key>id</key><value>messageutils_vector_pdu_xx_0</value></param>
<param><key>vector</key><value>ascii_bytes</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>type</key><value>b</value></param>
<param><key>tag_output</key><value>True</value></param>
<param><key>pkt_lim</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>messageutils_pdu_debug</key>
<param><key>id</key><value>messageutils_pdu_debug_0</value></param>
<param><key>vec_type</key><value>text</value></param>
<param><key>reverse_ascii</key><value>False</value></param>
<param><key>meta_only</key><value>False</value></param>
<param><key>display</key><value>True</value></param>
</block>
<connection><source_block_id>messageutils_vector_pdu_xx_0</source_block_id><sink_block_id>messageutils_pdu_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>messageutils_socket_pdu_repack</key>
<param><key>id</key><value>messageutils_socket_pdu_repack_0</value></param>
<param><key>vec_type</key><value>float</value></param>
<param><key>input</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>messageutils_pdu_debug</key>
<param><key>id</key><value>messageutils_pdu_debug_0</value></param>
<param><key>vec_type</key><value>float</value></param>
<param><key>reverse_ascii</key><value>True</value></param>
<param><key>meta_only</key><value>False</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>messageutils_vector_pdu_xx</key>
<param><key>id</key><value>messageutils_vector_pdu_xx_0</value></param>
<param><key>vector</key><value>[-1,1,-1,1,-1,1,-1,1]</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>type</key><value>f</value></param>
<param><key>tag_output</key><value>False</value></param>
<param><key>pkt_lim</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>messageutils_vector_pdu_xx</key>
<param><key>id</key><value>messageutils_vector_pdu_xx_0_0</value></param>
<param><key>vector</key><value>range(1,6)</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>type</key><value>b</value></param>
<param><key>tag_output</key><value>False</value></param>
<param><key>pkt_lim</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<connection><source_block_id>messageutils_vector_pdu_xx_0</source_block_id><sink_block_id>messageutils_socket_pdu_repack_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>messageutils_vector_pdu_xx_0</source_block_id><sink_block_id>messageutils_pdu_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>messageutils_socket_pdu_repack_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>messageutils_vector_pdu_xx_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
